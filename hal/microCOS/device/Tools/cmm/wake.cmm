do init
do sym
Break
r.s r0 0
go

